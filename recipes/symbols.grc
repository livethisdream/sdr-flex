options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'Soft symbols: a root-raised-cosine matched filter, read once a symbol on a fixed grid, centered and scaled so the outer levels sit at +-3. Output k is the filter at phase + k symbols; history is how many inputs come before the first instant. The grid, center and gain are fitted by SDR Flex, on each ten seconds of the capture.'
    generate_options: hb
    id: sdrflex_symbols
    output_language: python
    title: Symbol sync
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '48000'
  states: {}
- name: symbolRate
  id: parameter
  parameters:
    label: Symbol rate
    type: eng_float
    value: '4800'
  states: {}
- name: alpha
  id: parameter
  parameters:
    label: Roll-off
    type: eng_float
    value: '0.5'
  states: {}
- name: span
  id: parameter
  parameters:
    label: Filter span (symbols)
    type: intx
    value: '8'
  states: {}
- name: phase
  id: parameter
  parameters:
    label: Grid phase (samples)
    type: eng_float
    value: '0'
  states: {}
- name: center
  id: parameter
  parameters:
    label: Center
    type: eng_float
    value: '0'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '1'
  states: {}
- name: invert
  id: parameter
  parameters:
    label: Invert
    type: str
    value: 'no'
  states: {}
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: node
    node: core.symbols
    input: real
    output: real
    derived: phase=level-fit,center=level-fit,gain=level-fit
    history: history
    lead: half
    listen: 'no'
  states: {}
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: step
  id: variable
  parameters:
    value: samp_rate / symbolRate
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 2 * round(span * step / 2) + 1
  states: {}
- name: rrc
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0, samp_rate, symbolRate, alpha, ntaps)
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[t * (1 - alpha + 4 * alpha / math.pi) / math.sqrt(step) / max(rrc) for t in rrc]'
  states: {}
- name: half
  id: variable
  parameters:
    value: (ntaps - 1) // 2
  states: {}
- name: first
  id: variable
  parameters:
    value: phase
  states: {}
- name: skip
  id: variable
  parameters:
    value: int(math.floor(first))
  states: {}
- name: mu
  id: variable
  parameters:
    value: first - skip
  states: {}
- name: history
  id: variable
  parameters:
    value: half + 3
  states: {}
- name: sign
  id: variable
  parameters:
    value: '-1 if invert == ''yes'' else 1'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: fff
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: ntaps - 1 + skip
    type: float
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: mu
    resamp_ratio: step
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-center'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sign * gain
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}

connections:
- [pad_source_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
