options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'AM: the envelope, then the post-detection low-pass every receiver has, a moving average of smoothUs microseconds (40 by default, 0 for none) centered on its output so edges stay where they were. history is how many inputs come before the first whole output, lead how many after.'
    generate_options: hb
    id: sdrflex_am
    output_language: python
    title: AM demod
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '25000'
  states: {}
- name: smoothUs
  id: parameter
  parameters:
    label: Smoothing (us, 0 for none)
    type: eng_float
    value: '40'
  states: {}
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: node
    node: core.am_envelope
    input: iq
    output: real
    derived: ''
    history: history
    lead: lead
    listen: 'no'
  states: {}
- name: window_len
  id: variable
  parameters:
    value: 1 if smoothUs <= 0 else max(2, int(samp_rate * smoothUs * 1e-6 + 0.5))
  states: {}
- name: lead
  id: variable
  parameters:
    value: window_len // 2
  states: {}
- name: history
  id: variable
  parameters:
    value: window_len - 1 - lead
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_len
    max_iter: '4000'
    scale: 1.0 / window_len
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: lead
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}

connections:
- [pad_source_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
