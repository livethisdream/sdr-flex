options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'NRZ: the level against a threshold, sampled once a symbol on a fixed grid. Output k is the input at phase + k symbols, one bit per byte; history is how many inputs come before the first instant.'
    generate_options: hb
    id: sdrflex_nrz
    output_language: python
    title: NRZ slicer
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '48000'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0'
  states: {}
- name: symbolUs
  id: parameter
  parameters:
    label: Symbol (us)
    type: eng_float
    value: '1000'
  states: {}
- name: phase
  id: parameter
  parameters:
    label: Grid phase (samples)
    type: eng_float
    value: '0'
  states: {}
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: node
    node: core.nrz_slicer
    input: real
    output: bits
    derived: threshold=otsu,symbolUs=run-lengths,phase=grid-search
    history: history
    lead: ''
    listen: 'no'
  states: {}
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: step
  id: variable
  parameters:
    value: symbolUs * 1e-6 * samp_rate
  states: {}
- name: first
  id: variable
  parameters:
    value: phase
  states: {}
- name: skip
  id: variable
  parameters:
    value: int(math.floor(first))
  states: {}
- name: mu
  id: variable
  parameters:
    value: first - skip
  states: {}
- name: history
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-threshold'
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: skip
    type: float
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: mu
    resamp_ratio: step
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}

connections:
- [pad_source_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
