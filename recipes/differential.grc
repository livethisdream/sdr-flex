options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'Differential decoding, one bit per byte: NRZ-M (a 1 is a transition) or NRZ-S (a 0 is). GNU Radio''s diff_decoder_bb, whose first bit is read against a 0.'
    generate_options: hb
    id: sdrflex_differential
    output_language: python
    title: Differential decode
  states: {}

blocks:
- name: mode
  id: parameter
  parameters:
    label: Mode
    type: str
    value: nrz-m
  states: {}
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: node
    node: core.differential
    input: bits
    output: bits
    derived: ''
    history: ''
    lead: ''
    listen: 'no'
  states: {}
- name: invert
  id: variable
  parameters:
    value: 1 if mode == 'nrz-s' else 0
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: invert
    type: byte
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}

connections:
- [pad_source_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_and_const_xx_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
