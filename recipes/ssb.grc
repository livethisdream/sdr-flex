options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'SSB by the phasing method: the passband moved by the BFO, then I plus or minus the Hilbert transform of Q, plus for lower sideband and minus for upper, with I delayed to line up with the transformer. start_index is the capture sample the first input is; history is how many inputs come before the first whole output.'
    generate_options: hb
    id: sdrflex_ssb
    output_language: python
    title: SSB demod
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '25000'
  states: {}
- name: sideband
  id: parameter
  parameters:
    label: Sideband (usb or lsb)
    type: str
    value: usb
  states: {}
- name: bfoHz
  id: parameter
  parameters:
    label: BFO (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '6'
  states: {}
- name: start_index
  id: parameter
  parameters:
    hide: part
    label: Start index
    type: intx
    value: '0'
  states: {}
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: node
    node: core.ssb
    input: iq
    output: real
    derived: sideband=stronger-side
    history: history
    lead: ''
    listen: 'no'
  states: {}
- name: imports
  id: import
  parameters:
    imports: import cmath, math
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.hilbert(65, window.WIN_HAMMING)
  states: {}
- name: history
  id: variable
  parameters:
    value: len(taps) - 1
  states: {}
- name: sign
  id: variable
  parameters:
    value: 1 if sideband == 'lsb' else -1
  states: {}
- name: turn
  id: variable
  parameters:
    value: cmath.exp(-2j * math.pi * math.fmod(bfoHz * start_index, samp_rate) / samp_rate)
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: turn
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * math.pi * bfoHz / samp_rate'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: history // 2
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: fff
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: sign
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}

connections:
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_2, '0', pad_sink_0, '0']

metadata:
  file_format: 1
