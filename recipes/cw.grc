options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'CW (Morse): the carrier moved to zero, a low-pass of half the CW filter''s width, the carrier moved up to the pitch, the real part. A receiver''s CW filter and beat oscillator, as one hier block. start_index is the capture sample the first input is; history is how many inputs come before the first whole output.'
    generate_options: hb
    id: sdrflex_cw
    output_language: python
    title: CW (Morse)
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '25000'
  states: {}
- name: offsetHz
  id: parameter
  parameters:
    label: Carrier offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: pitchHz
  id: parameter
  parameters:
    label: Pitch (Hz)
    type: eng_float
    value: '700'
  states: {}
- name: filterHz
  id: parameter
  parameters:
    label: Filter width (Hz, 0 for none)
    type: eng_float
    value: '500'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '4'
  states: {}
- name: start_index
  id: parameter
  parameters:
    hide: part
    label: Start index
    type: intx
    value: '0'
  states: {}
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: node
    node: core.cw
    input: iq
    output: real
    derived: offsetHz=strongest-carrier
    history: history
    listen: 'no'
  states: {}
- name: imports
  id: import
  parameters:
    imports: import cmath, math
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0] if filterHz <= 0 or filterHz >= samp_rate / 2 else firdes.low_pass(1.0, samp_rate, filterHz / 2, filterHz / 2, window.WIN_HANN)'
  states: {}
- name: history
  id: variable
  parameters:
    value: len(taps) - 1
  states: {}
- name: turn
  id: variable
  parameters:
    value: cmath.exp(2j * math.pi * math.fmod((pitchHz - offsetHz) * start_index, samp_rate) / samp_rate)
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: turn
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * math.pi * offsetHz / samp_rate'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccf
  states: {}
- name: blocks_rotator_cc_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * pitchHz / samp_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}

connections:
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_rotator_cc_1, '0']
- [blocks_rotator_cc_1, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', pad_sink_0, '0']

metadata:
  file_format: 1
