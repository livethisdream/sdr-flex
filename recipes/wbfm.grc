options:
  parameters:
    author: SDR Flex
    category: '[SDR Flex]'
    description: 'WBFM broadcast: a broadcast FM station demodulated and decoded to left and right, with de-emphasis. In SDR Flex it expands into a chain you can open: a channel widthHz wide, an FM demod at deviationHz, a stereo decode, and Listen.'
    generate_options: hb
    id: sdrflex_wbfm
    output_language: python
    title: WBFM broadcast
  states: {}

blocks:
- name: recipe
  id: sdrflex_recipe
  parameters:
    kind: chain
    node: ''
    input: iq
    output: stereo
    derived: ''
    history: ''
    listen: 'yes'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '250000'
  states: {}
- name: widthHz
  id: parameter
  parameters:
    comment: 'The channel the station is tuned as: a broadcast station''s sidebands reach past 200 kHz, and a narrower channel costs stereo separation.'
    label: Channel width (Hz)
    type: eng_float
    value: '240000'
  states: {}
- name: deviationHz
  id: parameter
  parameters:
    comment: Broadcast FM's peak deviation.
    label: Deviation (Hz)
    type: eng_float
    value: '75000'
  states: {}
- name: deemphasisUs
  id: parameter
  parameters:
    comment: 75 in the Americas, 50 most other places.
    label: De-emphasis (us)
    type: eng_float
    value: '75'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: max(1, int(samp_rate // 48000))
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: audio_decim
    deemph_tau: deemphasisUs * 1e-6
    quad_rate: samp_rate
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: left
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: right
    type: float
  states: {}

connections:
- [pad_source_0, '0', analog_wfm_rcv_pll_0, '0']
- [analog_wfm_rcv_pll_0, '0', pad_sink_0, '0']
- [analog_wfm_rcv_pll_0, '1', pad_sink_1, '0']

metadata:
  file_format: 1
